## src/nova/u-boot/board/armltd/nova/Kconfig
```kconfig
if TARGET_NOVA

config SYS_BOARD
	default "nova"

config SYS_VENDOR
	default "armltd"

config SYS_CONFIG_NAME
	default "nova"

endif
```
